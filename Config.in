## Config.in
```kconfig
source "$BR2_EXTERNAL_macsecrouter_PATH/package/libnitrokey/Config.in"
source "$BR2_EXTERNAL_macsecrouter_PATH/package/nkmacsec/Config.in"
```
